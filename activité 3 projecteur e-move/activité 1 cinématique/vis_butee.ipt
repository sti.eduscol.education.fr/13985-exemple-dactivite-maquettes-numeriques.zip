# Autodesk Inventor part: vis_butee
## iProperties
Created: 2011-01
Part Number: vis_butee
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 0.201062 g
Surface Area: 2.26195 cm^2
Volume: 0.201062 cm^3
Author: eric
## Feature names
1. Base1
