# Autodesk Inventor part: flasque_stator
## iProperties
Created: 2011-01
Part Number: flasque_stator
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 16.0837 g
Surface Area: 59.2177 cm^2
Volume: 16.0837 cm^3
Author: eric
## Feature names
1. Base1
