# Autodesk Inventor part: Corniere_superieure
## iProperties
Created: 2011-01
Part Number: Corniere_superieure
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 1.19498 g
Surface Area: 25.8251 cm^2
Volume: 1.19498 cm^3
Author: eric
## Feature names
1. Base1
