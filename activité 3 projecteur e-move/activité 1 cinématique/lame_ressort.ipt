# Autodesk Inventor part: lame_ressort
## iProperties
Created: 2011-01
Part Number: lame_ressort
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 0.0720879 g
Surface Area: 3.2542 cm^2
Volume: 0.0720879 cm^3
Author: eric
## Feature names
1. Base1
