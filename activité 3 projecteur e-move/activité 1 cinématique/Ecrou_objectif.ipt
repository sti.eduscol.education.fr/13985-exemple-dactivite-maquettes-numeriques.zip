# Autodesk Inventor part: Ecrou_objectif
## iProperties
Created: 2011-01
Part Number: Ecrou_objectif
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 16.5509 g
Surface Area: 97.9497 cm^2
Volume: 16.5509 cm^3
Author: eric
## Feature names
1. Base1
