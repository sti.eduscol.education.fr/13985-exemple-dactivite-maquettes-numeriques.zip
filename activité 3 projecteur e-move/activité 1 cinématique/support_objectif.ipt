# Autodesk Inventor part: support_objectif
## iProperties
Created: 2011-01
Part Number: support_objectif
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 5.93719 g
Surface Area: 90.2329 cm^2
Volume: 5.93719 cm^3
Author: eric
## Feature names
1. Base1
