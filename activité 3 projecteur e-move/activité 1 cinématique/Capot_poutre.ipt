# Autodesk Inventor part: Capot_poutre
## iProperties
Created: 2011-01
Part Number: Capot_poutre
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 47.9413 g
Surface Area: 549.057 cm^2
Volume: 47.9413 cm^3
Author: eric
## Feature names
1. Base1
