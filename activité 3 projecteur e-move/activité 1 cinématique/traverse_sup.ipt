# Autodesk Inventor part: traverse_sup
## iProperties
Created: 2011-01
Part Number: traverse_sup
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 26.284 g
Surface Area: 284.211 cm^2
Volume: 26.284 cm^3
Author: eric
## Feature names
1. Base1
