# Autodesk Inventor part: capteur_temperature
## iProperties
Created: 2011-01
Part Number: capteur_temperature
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 2.21016 g
Surface Area: 9.48156 cm^2
Volume: 2.21016 cm^3
Author: eric
## Feature names
1. Base1
