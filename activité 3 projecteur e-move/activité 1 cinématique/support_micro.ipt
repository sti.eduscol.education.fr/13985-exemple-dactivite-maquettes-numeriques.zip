# Autodesk Inventor part: support_micro
## iProperties
Created: 2011-01
Part Number: support_micro
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 0.508938 g
Surface Area: 7.51489 cm^2
Volume: 0.508938 cm^3
Author: eric
## Feature names
1. Base1
