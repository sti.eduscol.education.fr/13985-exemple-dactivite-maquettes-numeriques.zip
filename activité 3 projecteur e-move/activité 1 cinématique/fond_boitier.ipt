# Autodesk Inventor part: fond_boitier
## iProperties
Created: 2011-01
Part Number: fond_boitier
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 211.798 g
Surface Area: 2891.52 cm^2
Volume: 211.798 cm^3
Author: eric
## Feature names
1. Base1
