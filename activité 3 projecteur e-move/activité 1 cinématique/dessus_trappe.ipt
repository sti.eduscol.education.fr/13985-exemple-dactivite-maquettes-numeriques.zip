# Autodesk Inventor part: dessus_trappe
## iProperties
Created: 2011-01
Part Number: dessus_trappe
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 10.7134 g
Surface Area: 219.712 cm^2
Volume: 10.7134 cm^3
Author: eric
## Feature names
1. Base1
