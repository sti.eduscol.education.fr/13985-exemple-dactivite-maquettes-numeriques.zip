# Autodesk Inventor part: Ecrou_arceau
## iProperties
Created: 2011-01
Part Number: Ecrou_arceau
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 3.33491 g
Surface Area: 24.5286 cm^2
Volume: 3.33491 cm^3
Author: eric
## Feature names
1. Base1
