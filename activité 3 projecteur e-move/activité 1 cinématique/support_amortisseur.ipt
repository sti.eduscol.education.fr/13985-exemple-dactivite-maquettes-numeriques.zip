# Autodesk Inventor part: support_amortisseur
## iProperties
Created: 2011-01
Part Number: support_amortisseur
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 2.42654 g
Surface Area: 13.079 cm^2
Volume: 2.42654 cm^3
Author: eric
## Feature names
1. Base1
