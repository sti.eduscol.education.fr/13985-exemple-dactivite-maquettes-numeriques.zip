# Autodesk Inventor part: moteur_disque
## iProperties
Created: 2011-01
Part Number: moteur_disque
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 30.8999 g
Surface Area: 79.5482 cm^2
Volume: 30.8999 cm^3
Author: eric
## Feature names
1. Base1
