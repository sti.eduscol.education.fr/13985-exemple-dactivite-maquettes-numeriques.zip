# Autodesk Inventor part: index_position
## iProperties
Created: 2011-01
Part Number: index_position
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 1.46943 g
Surface Area: 20.442 cm^2
Volume: 1.46943 cm^3
Author: eric
## Feature names
1. Base1
