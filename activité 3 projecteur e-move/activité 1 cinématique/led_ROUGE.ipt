# Autodesk Inventor part: led_ROUGE
## iProperties
Created: 2011-01
Part Number: led_ROUGE
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 0.146477 g
Surface Area: 1.52371 cm^2
Volume: 0.146477 cm^3
Author: eric
## Feature names
1. Base1
