# Autodesk Inventor part: Poutre_centrale
## iProperties
Created: 2011-01
Part Number: Poutre_centrale
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 110.961 g
Surface Area: 952.756 cm^2
Volume: 110.961 cm^3
Author: eric
## Feature names
1. Base1
