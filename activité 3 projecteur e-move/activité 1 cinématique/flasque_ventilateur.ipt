# Autodesk Inventor part: flasque_ventilateur
## iProperties
Created: 2011-01
Part Number: flasque_ventilateur
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 27.6735 g
Surface Area: 392.605 cm^2
Volume: 27.6735 cm^3
Author: eric
## Feature names
1. Base1
