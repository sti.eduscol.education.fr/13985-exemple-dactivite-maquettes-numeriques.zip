# Autodesk Inventor part: carte_afficheur
## iProperties
Created: 2011-01
Part Number: carte_afficheur
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 8.74853 g
Surface Area: 114.96 cm^2
Volume: 8.74853 cm^3
Author: eric
## Feature names
1. Base1
