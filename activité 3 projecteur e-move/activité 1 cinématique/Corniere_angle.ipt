# Autodesk Inventor part: Corniere_angle
## iProperties
Created: 2011-01
Part Number: Corniere_angle
Document SubType Name: Modeling
Designer: eric
Density: 1 g/cm^3
Mass: 1.71774 g
Surface Area: 25.4242 cm^2
Volume: 1.71774 cm^3
Author: eric
## Feature names
1. Base1
